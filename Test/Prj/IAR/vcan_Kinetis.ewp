# IAR project vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; IAR
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Chip\inc; ..\..\Chip\inc\kinetis; ..\..\Chip\inc\IAR; ..\..\Lib\CMSIS\Inc; ..\..\Lib\CMSIS; ..\..\Chip\src; ..\..\Chip\src\IAR; ..\..\Chip\src\IAR; ..\..\Board\inc; ..\..\Board\src; ..\..\Chip\inc; ..\..\Chip\inc\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; DEBUG; MK60DZ10; ARM_MATH_CM4
  ILINK.IlinkIcfFile: D:\k60学习资料\K60\UART_迪文液晶\Prj\IAR\config files\128KB_Ram.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c MK60_conf.c MK60_it.c
    ../../App/Inc/: MK60_conf.h MK60_it.h PORT_cfg.h
  group Board
    ../../Board/src/: LCDDriver.c LCDUart.c VCAN_key.c VCAN_LED.C
    ../../Board/inc/: LCDDriver.h LCDUart.h
  group Chip
    ../../Chip/inc/: common.h
    ../../Chip/src/: misc.c MK60_DWT.c MK60_flash.c MK60_gpio.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
